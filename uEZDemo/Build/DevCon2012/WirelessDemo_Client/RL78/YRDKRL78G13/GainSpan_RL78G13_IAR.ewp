# IAR project GainSpan_RL78G13_IAR.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 756
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: $PROJ_DIR$; ..
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group Apps
    ../Apps/: App_Common.c App_Connect.c App_COSM.c App_HTTPDemo.c App_Menu.c App_PassThroughSPI.c App_PassThroughUART.c App_ProgramMode.c App_Startup.c App_TCPClientDemo.c App_TCPServerDemo.c App_UDPDemo.c App_WirelessDemoClient.c Apps.h NVSettings.c NVSettings.h
  group CmdLib
    ../CmdLib/: AtCmdLib.c AtCmdLib.h GainSpan_SPI.c GainSpan_SPI.h
  group sensors
    ../Sensors/: Potentiometer.c Potentiometer.h Temperature.c Temperature.h
  group YRDKRL78G13/drv
    drv/: ADC.c ADC.h I2C.c I2C.h SAU.h SPI.c SPI.h Timer.c Timer.h UART0.c UART0.h UART2.c UART2.h
  group YRDKRL78G13/drv/Glyph
    drv/Glyph/: Glyph_API.h Glyph_cfg.h glyph_register.c glyph_types.h lcd.c lcd.h RL78GlyphLib_Debug.r87
  group YRDKRL78G13/drv/Glyph/Drivers
    drv/Glyph/Drivers/: ST7579_LCD.h
  group YRDKRL78G13/init
    init/: hwsetup.c hwsetup.h
  group YRDKRL78G13/system
    system/: console.c console.h EEPROM.c EEPROM.h GainSpan_IO.c GainSpan_IO.h mstimer.c mstimer.h platform.h Switch.c Switch.h YRDKRL78G13.h
