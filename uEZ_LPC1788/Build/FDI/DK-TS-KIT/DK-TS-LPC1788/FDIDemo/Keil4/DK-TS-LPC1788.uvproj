# Keil uVision project DK-TS-LPC1788.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: DK-TS-LPC1788 +hex
  c flags: Optim=2 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG
  c include: .;../../../../../../.;../../../../../../Source/App/DKTSKit;../../../../../../Source/App/uEZDemoCommon;../../../../../../Source/App/SEGGER/emWin/GUIDEMO;../../../../../../../uEZ;../../../../../../../uEZ/Include;../../../../../../../uEZ/Source/Platform/FDI/CARRIER_LPC1788;../../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx;../../../../../../../uEZ/Source/RTOS/FreeRTOS/include;../../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/RVDS/ARM_CM3;../../../../../../../uEZ/Source/Library/lwIP/src/include;../../../../../../../uEZ/Source/Library/lwIP/src;../../../../../../../uEZ/Source/Library/lwIP/Include;../../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4;../../../../../../../uEZ/Source/Platform/emWin/;../../../../../../../uEZ/Source/Platform/emWin/Config;../../../../../../../uEZ/Source/Platform/emWin/Inc;../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin;../../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Keil4/include;..\..\..\..\..\..\Source;..\..\..\..\..\..\Source\Data_Model;..\..\..\..\..\..\Source\CMSIS_modbus;..\..\..\..\..\..\Source\GUI;..\..\..\..\..\..\Source\modbus_lib;..\..\..\..\..\..\..\uEZ\Source\Library\Graphics\SWIM;..\..\..\..\..\..\Source\App\GUICommon;..\..\..\..\..\..\Source\App\Websockets;../../../../../../../uEZ/Source/Library/lwIP/src/include/lwip;../../../../../../../uEZ/Source/Library/lwIP/src/include/netif
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\DK-TS-LPC1788.sct
  link misc: --verbose
  group Build
    ./: Config_Build.h
  group Include
    ../../../../../Include/: Config.h
  group Source/App/DKTSKit
    ../../../../../../Source/App/DKTSKit/: AppTasks.c Audio.c FunctionalTest.c main.c MainMenu.c
  group Source/App/uEZDemoCommon
    ../../../../../../Source/App/uEZDemoCommon/: Calibration.c UDCImages.c NVSettings.c AppHTTPServer.c AppHTTPServer.h CANTest.c NetworkStartup.c NetworkStartup.h
  group Library
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Debug/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Release/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Release.lib
    ../../../../../../../uEZ/Build/Generic/NXP/LPC1788/FreeRTOS/Keil4.x/Debug-Trace/: uEZ_NXP_LPC1788_FreeRTOS_Keil_Debug-Trace.lib
    ../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin/Libraries/NXP/Keil/: emWin_522_Keil460_M3_LE.lib
  group Source/Platform/FDI/CARRIER_LPC1788
    ../../../../../../../uEZ/Source/Platform/FDI/CARRIER_LPC1788/: CARRIER_LPC1788.c
  group CMSIS_Modbus
    ../../../../../../Source/CMSIS_modbus/: bsp.c debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_timer.c lpc177x_8x_uart.c system_LPC177x_8x.c
  group GUI
    ../../../../../../Source/GUI/: debug_icon.c gui_task.c led_icon.c LedControlDLG.c menu_windowDLG.c Modbus_Master_testWindowDLG.c sensor_icon.c SensorsControlDLG.c
  group Modbus_lib
    ../../../../../../Source/modbus_lib/: init.c modbus_function.c modbus_task.c modbus.h
  group DataModel
    ../../../../../../Source/Data_Model/: datamodel.h
  group Websocket
    ../../../../../../Source/Websocket/: aw-base64.h aw-sha1.h websocket.c websocket.h
  group Http
    ../../../../../../Source/Http/: http.c http.h
target Release (ARM-ADS)
  device: LPC1778 NXP (founded by Philips)
  cpu: as above
  output: DK-TS-LPC1788 +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3
  c include: .;../../../../../../.;../../../../../../Source/App/DKTSKit;../../../../../../Source/App/uEZDemoCommon;../../../../../../Source/App/SEGGER/emWin/GUIDEMO;../../../../../../../uEZ;../../../../../../../uEZ/Include;../../../../../../../uEZ/Source/Platform/FDI/CARRIER_LPC1788;../../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx;../../../../../../../uEZ/Source/RTOS/FreeRTOS/include;../../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/RVDS/ARM_CM3;../../../../../../../uEZ/Source/Library/lwIP/src/include;../../../../../../../uEZ/Source/Library/lwIP/src;../../../../../../../uEZ/Source/Library/lwIP/Include;../../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4;../../../../../../../uEZ/Source/Platform/emWin/;../../../../../../../uEZ/Source/Platform/emWin/Config;../../../../../../../uEZ/Source/Platform/emWin/Inc;../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin;../../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Keil4/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\DK-TS-LPC1788.sct
  link misc: --verbose
target Debug-Trace (ARM-ADS)
  device: LPC1778 NXP (founded by Philips)
  cpu: as above
  output: DK-TS-LPC1788 +hex
  c flags: Optim=1 wLevel=1
  c define: COMPILER_TYPE=Keil4, GCC_ARMCM3, DEBUG,FREERTOS_PLUS_TRACE
  c include: .;../../../../../../.;../../../../../../Source/App/DKTSKit;../../../../../../Source/App/uEZDemoCommon;../../../../../../Source/App/SEGGER/emWin/GUIDEMO;../../../../../../../uEZ;../../../../../../../uEZ/Include;../../../../../../../uEZ/Source/Platform/FDI/CARRIER_LPC1788;../../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx;../../../../../../../uEZ/Source/RTOS/FreeRTOS/include;../../../../../../../uEZ/Source/RTOS/FreeRTOS/portable/RVDS/ARM_CM3;../../../../../../../uEZ/Source/Library/lwIP/src/include;../../../../../../../uEZ/Source/Library/lwIP/src;../../../../../../../uEZ/Source/Library/lwIP/Include;../../../../../../../uEZ/Source/Library/lwIP/src/include/ipv4;../../../../../../../uEZ/Source/Platform/emWin/;../../../../../../../uEZ/Source/Platform/emWin/Config;../../../../../../../uEZ/Source/Platform/emWin/Inc;../../../../../../../uEZ/Source/Library/GUI/SEGGER/emWin;../../../../../../../uEZ/Source/Processor/NXP/LPC17xx_40xx/Keil4/include;../../../../../../../uEZ/Source/RTOS/FreeRTOS-Plus/FreeRTOS-Plus-Trace/include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\DK-TS-LPC1788-Trace.sct
  link misc: --verbose
